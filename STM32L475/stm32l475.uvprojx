# Keil uVision project stm32l475.uvprojx, settings and files
target src (6190000::V6.19::ARMCLANG)
  device: STM32L475VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: stm32l475 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf --text -c -o "$L@L.txt" "#L"
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c include: .\inc\app;.\inc\bsp;.\inc\cmsis;.\inc\hal\Legacy;.\inc\hal;.\inc\startup
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group app
    ./src/app/: main.c
  group bsp
    ./src/bsp/: bsp_atk_pandora.c
  group hal
    ./src/hal/: stm32l4xx_hal.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c
  group startup
    ./src/startup/: system_stm32l4xx.c startup_stm32l475xx.s
